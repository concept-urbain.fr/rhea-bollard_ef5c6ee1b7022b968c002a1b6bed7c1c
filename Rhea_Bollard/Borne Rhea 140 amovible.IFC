Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Borne Rhea 140 amovible.IFC
Time: 2020-07-02T06:09:47
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: MULT-FOU-001_Default
In: Default Storey
Material: S235

# IfcBuildingElementProxy: RHEA-BOR-140-AMO-02-2_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 19.018; Area Measure: 1.15587; Volume Measure: 0.00243357

# IfcBuildingElementProxy: RHEA-BOR-140-AMO-03_Default
In: Default Storey
Material: AISI 304
