Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Borne Rhea 140 sur platine.IFC
Time: 2020-07-02T06:10:49
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: RHEA-BOR-140-001_Default
In: Default Storey
Material: S 235

# IfcBeam: RHEA-BOR-140-SP-002_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 11.1491; Area Measure: 0.567818; Volume Measure: 0.00144701

# IfcBuildingElementProxy: RHEA-BOR-140-SP-003_Default
In: Default Storey
Material: S 235
