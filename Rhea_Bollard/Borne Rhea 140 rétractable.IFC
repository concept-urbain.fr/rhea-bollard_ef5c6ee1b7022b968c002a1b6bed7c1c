Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Borne Rhea 140 rétractable.IFC
Time: 2020-07-02T06:10:16
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: MULT-BOR-RET-002_Default
In: Default Storey
Material: FGS 400-15
PSet_Mass_Property - Mass Measure: 68.1901; Area Measure: 4.46674; Volume Measure: 0.010324

# IfcBuildingElementProxy: MULT-BOR-RET-003_Default
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: MULT-BOR-RET-004_Default
In: Default Storey
Material: PE

# IfcBuildingElementProxy: MULT-BOR-RET-011_Default
In: Default Storey
Material: Laiton
