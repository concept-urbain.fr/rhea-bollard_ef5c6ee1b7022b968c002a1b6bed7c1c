Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Borne Rhea 200 amovible.IFC
Time: 2020-07-02T06:11:34
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: MULT-FOU-012_Default
In: Default Storey
Material: S235

# IfcBuildingElementProxy: RHEA-BOR-200-AMO-001-01_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 31.0161; Area Measure: 1.66976; Volume Measure: 0.00401122

# IfcBuildingElementProxy: RHEA-BOR-200-MUL-001_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: VEST-POT-MUL-001_Default
In: Default Storey
Material: S 235
