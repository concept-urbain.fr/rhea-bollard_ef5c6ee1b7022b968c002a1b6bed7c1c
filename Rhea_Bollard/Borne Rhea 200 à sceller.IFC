Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Borne Rhea 200 à sceller.IFC
Time: 2020-07-02T06:11:10
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: RHEA-BOR-200-MUL-001_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: RHEA-BOR-200-H65CM-AS-001-01_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 14.9114; Area Measure: 0.805951; Volume Measure: 0.00193477
